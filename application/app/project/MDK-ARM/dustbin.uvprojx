# Keil uVision project dustbin.uvprojx, settings and files
target GD32F307 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F307VE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dustbin +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL
  c include: ..\..\..\library\firmware\CMSIS;..\..\..\library\firmware\CMSIS\GD\GD32F30x\Include;..\..\..\library\firmware\CMSIS\GD\GD32F30x\Source\ARM;..\..\..\library\firmware\GD32F30x_standard_peripheral\Include;..\..\utilities\Third_Party\uCOS_III\uC-CPU;..\..\utilities\Third_Party\uCOS_III\uC-CPU\ARM-Cortex-M4\RealView;..\..\utilities\Third_Party\uCOS_III\uC-LIB;..\..\utilities\Third_Party\uCOS_III\uC-LIB\Ports;..\..\utilities\Third_Party\uCOS_III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\utilities\Third_Party\uCOS_III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\utilities\Third_Party\uCOS_III\uCOS-III\Source;..\..\utilities\Third_Party\uCOS_III\uCOS_BSP;..\..\utilities\Third_Party\uCOS_III\uCOS_CONFIG;..\..\utilities;..\inc;..\src;..\src\common;..\src\bsp\uart;..\src\bsp\gpio;..\src\bsp\adc;..\src\bsp\18b20;..\src\bsp\cs123x;..\src\task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group app
    ../src/: gd32f30x_it.c main.c systick.c
    ../src/common/: common.c
    ../src/task/: task_input.c
  group bsp
    ../src/bsp/uart/: bsp_uart.c
    ../src/bsp/gpio/: bsp_gpio.c
    ../src/bsp/adc/: bsp_adc.c
    ../src/bsp/18b20/: bsp_bs18b20.c
    ../src/bsp/cs123x/: bsp_cs123x.c
  group uC/OS-III CPU
    ../../utilities/Third_Party/uCOS_III/uC-CPU/: cpu_core.c
    ../../utilities/Third_Party/uCOS_III/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
  group uC/OS-III LIB
    ../../utilities/Third_Party/uCOS_III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../utilities/Third_Party/uCOS_III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III BSP
    ../../utilities/Third_Party/uCOS_III/uCOS_BSP/: bsp.c
  group uC/OS-III CFG
    ../../utilities/Third_Party/uCOS_III/uCOS_CONFIG/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_cfg.h os_cfg_app.h
  group uC/OS-III Port
    ../../utilities/Third_Party/uCOS_III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III Source
    ../../utilities/Third_Party/uCOS_III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group peripherals
    ../../../library/firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group startup
    ../../../library/firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group cmsis
    ../../../library/firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
